# Keil uVision project Am32F031.uvprojx, settings and files
target AM32REF_F031 (6190000::V6.19::ARMCLANG)
  device: STM32F031C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: AM32REF_F031 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F031x6,USE_FULL_LL_DRIVER, REF_F031
  c include: ..\mcu\f031\Drivers\CMSIS\Include;..\mcu\f031\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\mcu\f031\Drivers\STM32F0xx_HAL_Driver\Inc;..\mcu\f031\Inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x200000c0 size 0x1000
  scatter file: ..\Mcu\F031\Am32 32kb_f051.sct
  group startup
    ../Mcu/F031/Startup/mdk/: startup_stm32f031c6tx.s
  group Src
    ../Src/: dshot.c functions.c main.c signal.c sounds.c firmwareversion.c
  group f031
    ../Mcu/F031/Src/: ADC.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c serial_telemetry.c stm32f0xx_it.c system_stm32f0xx.c
  group Drivers/STM32F0xx_LL_Driver
    ../Mcu/f051/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_adc.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
target CRAWLMASTER_F031 (6190000::V6.19::ARMCLANG)
  device: STM32F031C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: as above
  output: CRAWLMASTER_F031 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F031x6,USE_FULL_LL_DRIVER, CRAWLMASTER_F031
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x200000c0 size 0x1000
  scatter file: ..\Mcu\F031\Am32 32kb_f051.sct
software components: CMSIS:CORE 5.5.0
