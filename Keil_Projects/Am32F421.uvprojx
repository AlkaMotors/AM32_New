# Keil uVision project Am32F421.uvprojx, settings and files
target AT32DEV_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: AM32_AT32DEV_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AT32DEV_F421
  c include: ..\Inc;..\mcu\f421\Inc;..\Mcu\f421\Drivers\drivers\inc;..\Mcu\f421\Drivers\CMSIS\cm4\device_support;..\Mcu\f421\Drivers\CMSIS\cm4\core_support
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
  group Src
    ../Src/: dshot.c functions.c main.c signal.c sounds.c firmwareversion.c
  group Drivers
    ../Mcu/f421/Drivers/drivers/src/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c
  group F421
    ../Mcu/f421/Src/: ADC.c at32f421_it.c comparator.c eeprom.c IO.c peripherals.c phaseouts.c serial_telemetry.c system_at32f421.c WS2812.c
  group Startup
    ../Mcu/f421/Startup/mdk/: startup_at32f421.s
target TEKKO32_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_TEKKO32_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, TEKKO32_F421
  c include: as above
  asm misc: --target=arm-arm-none-eabi
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target AIKON_SINGLE (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_AIKON_SINGLE_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AIKON_SINGLE_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target FOXEER (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_FOXEER_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, FOXEER_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target AIKON_55A (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_AIKON_55A_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AIKON_55A_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target HAKRC_KB (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_HAKRC_K_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, HAKRC_K_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target HAKRC_GB (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_HAKRC_G_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, HAKRC_G_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target SWAP_PWM_PIN (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_SWAP_PB0_PA7_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, SWAP_PB0_PA7_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target AT32F421_PB4_054 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_AT32PB4_054_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER,AT32PB4_054_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target AT32F421_PB4_405 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_AT32PB4_405_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AT32PB4_405_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target AT32F421_PB4_540 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_AT32PB4_540_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AT32PB4_540_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target F4A_AIO (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_F4A_AIO_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, F4A_AIO_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target F4A_4IN1 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_F4A_4IN1_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, F4A_4IN1_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target SLOTCAR_G (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_AT32SLOTCAR_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AT32SLOTCAR_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target F4A_EXTCOMP (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_F4A_EXTCOMP_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, F4A_EXTCOMP_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target HAKRC_G23 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_HAKRC_G23_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, HAKRC_G23_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target NEUTRON_1_2S_MINIAIO (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_NEUTRON_1_2S_AIO_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, NEUTRON_1_2S_AIO_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target NEUTRON_2_6S_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_NEUTRON_2_6S_AIO_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, NEUTRON_2_6S_AIO_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target FLASHHOBBY_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_FLASHHOBBY_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, FLASHHOBBY_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target DAKEFPV_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_DAKEFPV_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, DAKEFPV_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target TBS_MINI_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_TBS_MINI_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, TBS_MINI_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target NEUTRON_4IN1_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_NEUTRON_4IN1_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, NEUTRON_4IN1_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target RR_ROBOT_DUAL_ESC (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_RR_ROBOT_DUAL_ESC_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, RR_ROBOT_DUAL_ESC_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target GiPSy_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_GIPSY_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, GIPSY_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target SKYSTARS_AM60_V2_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_SKYSTARS_AM60_V2_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, SKYSTARS_AM60_V2_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target TBS_12S_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_TBS_12S_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, TBS_12S_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target FLYROTOR_150A (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_FLYROTOR_150A_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, FLYROTOR_150A_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target SPEEDYBEE_65A_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_SPEEDYBEE_65A_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, SPEEDYBEE_65A_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target SKYSTARS_MVP60_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_SKYSTARS_MVP60_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, SKYSTARS_MVP60_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target SPEDIX_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_SPEDIX_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, SPEDIX_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target GSPACE_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_GSPACE_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, GSPACE_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target JMITEST_1_2S_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_JMITEST_1_2S_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, JMITEST_1_2S_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target SEQURE_TEST_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_SEQURE_TEST_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, SEQURE_TEST_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target TBS_6S_4IN1_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_TBS_6S_4IN1_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, TBS_6S_4IN1_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target AIRBEE_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_AIRBEE_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AIRBEE_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target IFLIGHT_TEST_F4A (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_IFLIGHT_TEST_F4A +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, IFLIGHT_TEST_F4A
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target AT_F4_04_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_AT_F4_04_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AT_F4_04_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target SKYSTARS_AM60_THRUSTER_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_SKYSTARS_AM60_THRUSTER_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, SKYSTARS_AM60_THRUSTER_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target AORC_K_A_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_AORC_K_A_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AORC_K_A_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target AORC_G_A_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_AORC_G_A_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, AORC_G_A_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target BAYCKRC_S_55A_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_BAYCKRC_S_55A_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, BAYCKRC_S_55A_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target FLYWOO_F4A_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_FLYWOO_F4A_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, FLYWOO_F4A_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target FLYWOO_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_FLYWOO_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, FLYWOO_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target SKYSTARS_KM55_V2_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_SKYSTARS_KM55_V2_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, SKYSTARS_KM55_V2_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target F4A_ZERODRAG_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_F4A_ZERODRAG_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, F4A_ZERODRAG_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target MAMBA_F45_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_MAMBA_F45_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, MAMBA_F45_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target MAMBA_REACTOR66_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_MAMBA_REACTOR66_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, MAMBA_REACTOR66_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target MAMBA_F55_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_MAMBA_F55_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, MAMBA_F55_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target MAMBA_F65_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_MAMBA_F65_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, MAMBA_F65_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target JUPITER_50A_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_JUPITER_50A_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, JUPITER_50A_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target GEPRC_4IN1_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_GEPRC_4IN1_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, GEPRC_4IN1_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target NEUTRON_SINGLE_L431 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_NEUTRON_SINGLE_L431 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, NEUTRON_SINGLE_L431
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target F4A_RUSH_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_F4A_RUSH_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, F4A_RUSH_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target JHEMCU_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_JHEMCU_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, JHEMCU_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target SKYSTARS_KO60_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_SKYSTARS_KO60_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, SKYSTARS_KO60_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target TEKKO32_4IN1_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_TEKKO32_4IN1_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, TEKKO32_4IN1_F421
  c include: as above
  asm misc: --target=arm-arm-none-eabi
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target F4A_SINGLE_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_F4A_SINGLE_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, F4A_SINGLE_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
target TBS_8S_4IN1_F421 (6190000::V6.19::ARMCLANG)
  device: -AT32F421K8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.5
  cpu: as above
  output: AM32_TBS_8S_4IN1_F421 +hex
  c flags: Optim=4 OneElfS=1 wLevel=3
  c define: AT32F421K8U7,USE_STDPERIPH_DRIVER, TBS_8S_4IN1_F421
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\Mcu\f421\Am32.sct
